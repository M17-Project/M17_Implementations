options:
  parameters:
    author: sp5wwp
    generate_options: qt_gui
    id: symbol_recovery
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sp5wwp/Desktop/symb_fifo
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/ttyUSB0
    repeat: 'False'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.05'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '1'
    size: 200*1
    srate: symbol_rate*1
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: symbol_rate*5
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: 1/0.12
    ntaps: 8*5+1
    samp_rate: '5'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}

connections:
- [blocks_char_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
