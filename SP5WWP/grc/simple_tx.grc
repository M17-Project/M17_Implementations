options:
  parameters:
    author: sp5wwp
    generate_options: qt_gui
    id: simple_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: samples/1.aud
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: samples/1.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: samp_rate*16
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(433475000*(1+2.75e-6))
    samplerate: samp_rate*16
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: ALL
    meta: helloworld
    src_id: AB1CDE
    type: '5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate*16
    center_freq0: int(433475000*(1+2.75e-6))
    dev_addr: ''
    gain0: '60'
    samp_rate: samp_rate*16
    sync: sync
    type: fc32
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_file_source_1, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', m17_m17_coder_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_vector_source_x_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [m17_m17_coder_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
