options:
  parameters:
    author: sp5wwp
    generate_options: qt_gui
    id: simple_loopback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../payload.bin
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15)
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: ALL
    meta: helloworld
    src_id: AB1CDE
    type: '5'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug_ctrl: 'False'
    debug_data: 'False'
    threshold: '0.9'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', m17_m17_coder_0, '0']
- [m17_m17_coder_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
