options:
  parameters:
    author: SP5WWP
    generate_options: qt_gui
    id: pkt_tx
    output_language: python
    title: Simple packet transmitter
  states: {}

blocks:
- name: ppm
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: out.rrc
    repeat: 'False'
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '7168.0'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: samp_rate*16
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(433475000*(1+ppm*1e-6))
    samplerate: samp_rate*16
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate*16
    center_freq0: int(433475000*(1+2.75e-6))
    dev_addr: ''
    gain0: '60'
    samp_rate: samp_rate*16
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_frequency_modulator_fc_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
