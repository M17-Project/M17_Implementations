options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project, Jun 2024
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 data streamer
  states: {}

blocks:
- name: can
  id: variable
  parameters:
    value: '0'
  states: {}
- name: encr
  id: variable
  parameters:
    value: '2'
  states: {}
- name: encr_sub
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sign
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo0
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Codec 2 encoded raw .bin file (with no header)
    file: /media/sf_vm_share/c2_1.bin
    repeat: 'False'
    type: byte
    vlen: '16'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (6, 6, 2, 14, 16)
    num_inputs: '5'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maximum: 6+6+2+14+16
    maxoutbuf: 6+6+2+14+16
    samples_per_second: (6+6+2+14+16)*(1000/40)
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x1F, 0x24, 0x5D, 0x51)
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: ((sign<<3)|(can>>1), ((can&1)<<7)|(encr_sub<<5)|(encr<<3)|(2<<1)|(1<<0))
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: DST
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SRC
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: TYPE
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: note_0_2_0
  id: note
  parameters:
    note: META
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_0_1, '0', blocks_stream_mux_0, '2']
- [blocks_vector_source_x_0_2, '0', blocks_stream_mux_0, '4']
- [blocks_vector_source_x_0_2_0, '0', blocks_stream_mux_0, '3']
- [blocks_vector_to_stream_0, '0', blocks_stream_mux_0, '4']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
